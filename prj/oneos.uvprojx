# Keil uVision project oneos.uvprojx, settings and files
target oneos (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: oneos
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\app;..\bsp;..\common;..\config;..\libs\STM32F10x_StdPeriph_Driver\inc;..\libs\CMSIS;..\oneos;..\libs\CMSIS\startup;..\RTT;..\oneos\kernel\include;..\oneos\cpu
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../libs/CMSIS/startup/: core_cm3.c startup_stm32f10x_hd.s
    ../libs/CMSIS/: system_stm32f10x.c
  group app
    ../app/: stm32f10x_it.c main.c
  group bsp
    ../bsp/: bsp.c
  group config
    ../config/: stm32f10x_conf.h oneos_config.h
  group devices
    ../devices/: drvcommon.c
  group libs
    ../libs/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group cpu
    ../oneos/cpu/: cpuport.c cortexm_common.c exc.c context_rvds.S
  group kernel
    ../oneos/kernel/source/: os_clock.c os_event.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mailbox.c os_mem_small.c os_mq.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group readme
    ../: readme.md
